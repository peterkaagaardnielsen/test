# Keil uVision project Bootloader.uvproj, settings and files
target Dragonfly (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: EFM32GG230F512 Energy Micro
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: Bootload +hex
  AfterMake: "$KARM\ARMCC\BIN\fromelf.exe" --bin -o @L.bin OBJ\@L.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: EFM32GG230F512 nDEBUG _KEIL_ARTX_ _DRAGONFLY_ TARGET=9
  c include: C:\Keil\ARM\RV31\INC;.\SRC\chanFS;.\SRC
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Bootloader.sct
  group Source Group 1
    ./SRC/: main.c PMon.c SMon.c Debug.c CRC16.c WDT.C stringutil.c Clock.c RF.c DESP.c DataWhitening.c
    ./: system_efm32gg.c startup_efm32gg.s Retarget.c
  group peripherals
    ./SRC/: RTC.c IAP.c uart0.c ADC.C GSM.C leuart0.c si4461.c SPI2.C GPIOIRQ.c
  group RTOS
    ./SRC/: RTX_Conf_CM.c
  group FileSystem
    ./SRC/hcc/src/config/: config_tiny.h
    ./SRC/hcc/src/oal/os/: oalp_event.c oalp_isr.c oalp_mutex.c oalp_task.c
    ./SRC/hcc/src/psp/target/rtc/: psp_rtc.c
    ./SRC/hcc/src/psp/target/spi/: psp_spi.c
    ./SRC/hcc/src/tiny/common/: f_dir.c f_file.c f_rtos.c f_util.c f_volume.c
    ./SRC/hcc/src/tiny/driver/atmel/df/single/: f_atmel.c
    ./SRC/hcc/src/psp/board/init/: target.c
target DK3750 (ARM-ADS)
  device: EFM32GG230F512 Energy Micro
  cpu: as above
  output: Bootload
  AfterMake: "$KARM\ARMCC\BIN\fromelf.exe" --bin -o @L.bin OBJ\@L.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: EFM32GG230F512 nDEBUG _KEIL_ARTX_ _MOSQUITO_ TARGET=9 DK3750
  c include: C:\Keil\ARM\RV31\INC;.\SRC\chanFS;.\SRC
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Bootloader.sct
